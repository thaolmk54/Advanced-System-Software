# Keil uVision project MusicPlayer_Thao_Yan_Melvin.uvprojx, settings and files
target MusicPlayer_Thao_Yan_Melvin (ARM-ADS)
  device: LPC1768 NXP
  pack: Keil.LPC1700_DFP.2.1.0
  cpu: IROM(0x00000000,0x80000) IRAM(0x10000000,0x8000) IRAM2(0x2007C000,0x8000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: MusicPlayer_Thao_Yan_Melvin
  c flags: Optim=2 uC99=1
  c misc: -DDEVICE_RTC=1 -DDEVICE_SLEEP=1 -DTOOLCHAIN_object -DTOOLCHAIN_ARM_STD -DDEVICE_SEMIHOST=1 -D__ASSERT_MSG -DTARGET_LPC1768 -DTARGET_RELEASE --no_rtti -Otime -DDEVICE_PORTINOUT=1 -D__CORTEX_M3 -DDEVICE_DEBUG_AWARENESS=1 -DTARGET_M3 -c -O3 -DDEVICE_CAN=1 -DDEVICE_PORTOUT=1 -DDEVICE_STDIO_MESSAGES=1 -DDEVICE_ANALOGOUT=1 --split_sections -DARM_MATH_CM3 -DTARGET_LIKE_CORTEX_M3 -DDEVICE_ANALOGIN=1 -DDEVICE_PORTIN=1 -DTARGET_CORTEX_M -DDEVICE_ERROR_PATTERN=1 --cpu=Cortex-M3 -DDEVICE_ETHERNET=1 -DDEVICE_I2C=1 --preinclude=mbed_config.h -DTOOLCHAIN_ARM -DDEVICE_INTERRUPTIN=1 --no_depend_system_headers -DTARGET_UVISOR_UNSUPPORTED --md -DDEVICE_PWMOUT=1 -DTARGET_LIKE_MBED --gnu -DMBED_BUILD_TIMESTAMP=1481809816.74 --apcs=interwork -DDEVICE_SPI=1 -D__MBED__=1 -DDEVICE_SPISLAVE=1 -DDEVICE_SERIAL_FC=1 -DDEVICE_LOCALFILESYSTEM=1 -DDEVICE_SERIAL=1 -DTARGET_LPC176X -DDEVICE_I2CSLAVE=1 -D__CMSIS_RTOS -DTARGET_NXP -DTARGET_MBED_LPC1768 -D__MBED_CMSIS_RTOS_CM
  c include: .; C12832; PinDetect; USBHost; USBHost/USBHost; USBHost/USBHost3GModule; USBHost/USBHostHID; USBHost/USBHostHub; USBHost/USBHostMSD; USBHost/USBHostSerial; USBHost/FATFileSystem; USBHost/FATFileSystem/ChaN; USBHost/mbed-rtos; USBHost/mbed-rtos/rtos; USBHost/mbed-rtos/rtx; USBHost/mbed-rtos/rtx/TARGET_M3; USBHost/mbed-rtos/rtx/TARGET_M3/TOOLCHAIN_ARM; wave_player; mbed/.; mbed/TARGET_LPC1768; mbed/TARGET_LPC1768/TOOLCHAIN_ARM_STD;
  asm misc: --cpreproc --cpreproc_opts=-D__ASSERT_MSG,-D__CORTEX_M3,-D__CMSIS_RTOS,-DARM_MATH_CM3,-D__MBED_CMSIS_RTOS_CM
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
  scatter file: mbed/TARGET_LPC1768/TOOLCHAIN_ARM_STD/LPC1768.sct
  group C12832
    C12832/: C12832.cpp C12832.h GraphicsDisplay.cpp GraphicsDisplay.h Small_7.h TextDisplay.cpp TextDisplay.h
  group ChaN
    USBHost/FATFileSystem/ChaN/: ccsbcs.cpp diskio.cpp diskio.h ff.cpp ff.h ffconf.h integer.h
  group FATFileSystem
    USBHost/FATFileSystem/: FATDirHandle.cpp FATDirHandle.h FATFileHandle.cpp FATFileHandle.h FATFileSystem.cpp FATFileSystem.h
  group MusicPlayer_Thao_Yan_Melvin
    ./: main.cpp mbed_config.h ReadTime.h
  group PinDetect
    PinDetect/: ChangeLog.h example.h PinDetect.h
  group TARGET_LPC1768
    mbed/TARGET_LPC1768/: cmsis.h cmsis_nvic.h core_cm0.h core_cm0plus.h core_cm3.h core_cm4.h core_cm4_simd.h core_cmFunc.h core_cmInstr.h device.h gpio_object.h LPC17xx.h objects.h PeripheralNames.h PinNames.h PortNames.h reserved_pins.h system_LPC17xx.h
  group TOOLCHAIN_ARM
    USBHost/mbed-rtos/rtx/TARGET_M3/TOOLCHAIN_ARM/: HAL_CM3.c SVC_Table.s
  group TOOLCHAIN_ARM_STD
    mbed/TARGET_LPC1768/TOOLCHAIN_ARM_STD/: cmsis_nvic.o mbed.ar retarget.o startup_LPC17xx.o sys.o system_LPC17xx.o
  group USBHost
    USBHost/USBHost/: dbg.h IUSBEnumerator.h USBDeviceConnected.cpp USBDeviceConnected.h USBEndpoint.cpp USBEndpoint.h USBHALHost.cpp USBHALHost.h USBHost.cpp USBHost.h USBHostConf.h USBHostTypes.h
  group USBHost3GModule
    USBHost/USBHost3GModule/: IUSBHostSerial.h IUSBHostSerialListener.h WANDongle.cpp WANDongle.h WANDongleInitializer.h WANDongleSerialPort.cpp WANDongleSerialPort.h
  group USBHostHID
    USBHost/USBHostHID/: USBHostKeyboard.cpp USBHostKeyboard.h USBHostMouse.cpp USBHostMouse.h
  group USBHostHub
    USBHost/USBHostHub/: USBHostHub.cpp USBHostHub.h
  group USBHostMSD
    USBHost/USBHostMSD/: USBHostMSD.cpp USBHostMSD.h
  group USBHostSerial
    USBHost/USBHostSerial/: MtxCircBuffer.h USBHostSerial.cpp USBHostSerial.h
  group mbed
    mbed/: AnalogIn.h analogin_api.h AnalogOut.h analogout_api.h BusIn.h BusInOut.h BusOut.h CallChain.h CAN.h can_api.h can_helper.h DigitalIn.h DigitalInOut.h DigitalOut.h DirHandle.h error.h Ethernet.h ethernet_api.h FileBase.h FileHandle.h FileLike.h FilePath.h FileSystemLike.h FunctionPointer.h gpio_api.h gpio_irq_api.h I2C.h i2c_api.h I2CSlave.h InterruptIn.h InterruptManager.h LocalFileSystem.h mbed.h mbed_debug.h mbed_interface.h pinmap.h platform.h port_api.h PortIn.h PortInOut.h PortOut.h PwmOut.h pwmout_api.h RawSerial.h rtc_api.h rtc_time.h semihost_api.h Serial.h serial_api.h SerialBase.h sleep_api.h SPI.h spi_api.h SPISlave.h Stream.h Ticker.h Timeout.h Timer.h TimerEvent.h toolchain.h us_ticker_api.h wait_api.h
  group rtos
    USBHost/mbed-rtos/rtos/: Mail.h MemoryPool.h Mutex.cpp Mutex.h Queue.h rtos.h RtosTimer.cpp RtosTimer.h Semaphore.cpp Semaphore.h Thread.cpp Thread.h
  group rtx
    USBHost/mbed-rtos/rtx/: cmsis_os.h HAL_CM.c os_tcb.h rt_CMSIS.c rt_Event.c rt_Event.h rt_HAL_CM.h rt_List.c rt_List.h rt_Mailbox.c rt_Mailbox.h rt_MemBox.c rt_MemBox.h rt_Mutex.c rt_Mutex.h rt_Robin.c rt_Robin.h rt_Semaphore.c rt_Semaphore.h rt_System.c rt_System.h rt_Task.c rt_Task.h rt_Time.c rt_Time.h rt_TypeDef.h RTX_CM_lib.h RTX_Conf.h RTX_Conf_CM.c
  group wave_player
    wave_player/: wave_player.cpp wave_player.h
